require dnsmasq.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263 \
                    file://COPYING-v3;md5=d32239bcb673463ab874e80d47fae504"

SRC_URI[dnsmasq-2.93.md5sum] = "2d9785f1fda6f59239d58701c865f3ac"
SRC_URI[dnsmasq-2.93.sha256sum] = "cc967771abdafeb43d10db18932d6b59fd4bed2c69c22acf8cb96aff6920d55f"
