FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append += " file://0002-RDKB-42894-UPnP-Refactor-is-configuring-as-false-whi.patch"
