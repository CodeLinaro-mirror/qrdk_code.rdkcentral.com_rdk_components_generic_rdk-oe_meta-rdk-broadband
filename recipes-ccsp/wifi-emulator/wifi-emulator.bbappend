FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://get_ssl_config.patch"
SRC_URI += "file://image_upgrade_and_factory_reset.patch"

